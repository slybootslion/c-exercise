# Keil uVision project arm-asm.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: arm-asm
  group Source Group 1
    ./: asm.s add.c
