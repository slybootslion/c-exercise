//
// Created by SlybootsLion on 2022/8/22.
//

#include "head.h"

//shape[7][4][18]
//7---7 表示方块 的 7 中基本形状。
//4---表示方块的 4 个方向的旋转。
//18---前 16 个整数表示 4*4 的方块的形状，后两 个变量，表示距离右侧空格个数和距离下方空格个数
//值：1表示绘制该点,0表示不绘制该点。
int shape[7][4][18] =
        {
                {
                        {1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 2},                //
                        {1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 2},                //
                        {1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 2},                //[][]
                        {1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 2},                //[][]
                },
                {
                        {1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 3, 0},               //[]  [][][][]
                        {1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3},               //[]
                        {1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 3, 0},               //[]
                        {1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3},               //[]
                },
                {
                        {0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2},               //  []    []      [][][]     []
                        {1, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 2, 1},               //[][][]  [][]      []     [][]
                        {1, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2},               //        []                 []
                        {0, 1, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 2, 1}                //
                },
                {
                        {1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2},               //[][]       []
                        {0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 2, 1},               //  [][]   [][]
                        {1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2},               //         []
                        {0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 2, 1},               //
                },
                {
                        {0, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2},               //  [][]   []
                        {1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 2, 1},               //[][]     [][]
                        {0, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2},               //           []
                        {1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 2, 1},               //
                },
                {
                        {0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2},               //    []   []    [][][]  [][]
                        {1, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 2, 1},               //[][][]   []    []        []
                        {1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2},               //         [][]            []
                        {1, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 2, 1}                //
                },
                {
                        {1, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2},               //[]       [][]  [][][]      []
                        {1, 1, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 2, 1},               //[][][]   []        []      []
                        {1, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2},               //         []              [][]
                        {0, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 2, 1}},              //
        };

void print_block(const int *block, int x, int y, int color) {
    int bx = x;
    for (int i = 0; i < 16; ++i) {
        if (i != 0 && i % 4 == 0) {
            bx = x;
            y += 1;
        }
        if (block[i] == 1) {
            printf("\033[%d;%dH", y, bx);
            printf("\033[37;%dm.`", color);
            printf("\033[0m");
        }
        bx += 2;
    }
}

int main() {
    printf("\033[2J");
    int x = 4, y = 2;
    int colors[4] = {43, 44, 45, 46};
    for (int i = 0; i < 7; ++i) {
        for (int j = 0; j < 4; ++j) {
            print_block(shape[i][j], x, y, colors[j]);
            x += 10;
        }
        x = 4;
        y += 5;
    }
    printf("\n");
    return 0;
}
